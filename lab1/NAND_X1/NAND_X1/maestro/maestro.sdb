<?xml version="1.0"?>
<setupdb version="7">maestro
	<active>Active Setup
		<corners>
			<corner enabled="1">_default</corner>
		</corners>
		<sharedvarinfo></sharedvarinfo>
	</active>
	<history>History</history>
</setupdb>
